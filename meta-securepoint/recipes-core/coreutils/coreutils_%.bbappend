bindir_progs_remove = " nice "
