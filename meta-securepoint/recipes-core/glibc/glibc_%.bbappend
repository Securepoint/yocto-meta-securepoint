FULL_OPTIMIZATION = "-O2 -pipe ${DEBUG_FLAGS}"
