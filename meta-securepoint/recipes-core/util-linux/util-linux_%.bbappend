ALTERNATIVE_PRIORITY[logger] = "10"
# remove installation of extra tools
#RRECOMMENDS_${PN} = "util-linux-fdisk util-linux-cfdisk util-linux-sfdisk util-linux-mount util-linux-readprofile util-linux-mkfs util-linux-mountpoint util-linux-prlimit"
RRECOMMENDS_${PN} = ""
