FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

dirs755 += " /rootdisk /root "
