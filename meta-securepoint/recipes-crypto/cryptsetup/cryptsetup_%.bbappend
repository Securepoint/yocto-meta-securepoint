EXTRA_OECONF += "--disable-udev"
