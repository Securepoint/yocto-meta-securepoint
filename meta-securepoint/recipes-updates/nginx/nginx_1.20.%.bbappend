FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
DEFAULT_PREFERENCE = "-1"

