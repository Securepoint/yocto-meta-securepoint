FILES:${PN}-dev += " /usr/share/ghostscript/${PV}/doc/ \
/usr/share/ghostscript/${PV}/examples/"
