DEPENDS:remove = "readline"
DEPENDS += "libedit"
