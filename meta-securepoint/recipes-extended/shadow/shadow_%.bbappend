RDEPENDS:${PN}:remove = "util-linux-sulogin"
