require dnsmasq.inc

PR = "r3"

SRC_URI[md5sum] = "0256e0a71e27c8d8a5c89a0d18f3cfe2"
SRC_URI[sha256sum] = "7d0bd23f5d74b3a6b26a75d5ffcf9db81d461b47cbe578cb65a83a98008600b1"
