require openvpn.inc

SRC_URI[md5sum] = "69daeec663aca29c1d7a8e43bb2b84cb"
SRC_URI[sha256sum] = "22326f80fde07badec9c4b967ed40d818491e1a2f75d49d4444813e30952852b"
