require openvpn.inc

SRC_URI[md5sum] = "000561d71d24b28d0c79210a70cea202"
SRC_URI[sha256sum] = "7f412b9e881dcf5b501dc0e7e06d92d831912da82a38bd9c54b1c2dcbaa2aede"
