require openvpn.inc

SRC_URI[md5sum] = "fb5f14f15e0eb60f9c621716c416e57b"
SRC_URI[sha256sum] = "f06eb580b062492f0336c7bee208e9223f37986d6978e1d63543109bc5bd2e73"
