FILES:${PN}-cli  += " ${sbindir}/genl-ctrl-list"
FILES:${PN}-genl  = "${libdir}/libnl-genl-3.so.* ${libdir}/libnl-genl.so.*"
