# Do not edit. This file simply exists to set the extra pathes!
FILESEXTRAPATHS_prepend := "${THISDIR}/files:${THISDIR}/${PN}-${PV}:"
