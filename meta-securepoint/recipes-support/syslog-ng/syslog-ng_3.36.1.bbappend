# Do not edit. This file simply exists to set the extra pathes!
FILESEXTRAPATHS:prepend := "${THISDIR}/files:${THISDIR}/${PN}-${PV}:"
