#remove systemd deps
DEPENDS = "openssl"
REQUIRED_DISTRO_FEATURES = ""

