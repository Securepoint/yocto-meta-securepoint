SRC_URI[md5sum] = "f06a559e4146c3d5b5357bfa970f4070"
SRC_URI[sha256sum] = "8ac32e910aa744cc7f921c5122ba523ef1ffbbbf94545f94fc4a976b502be74b"

require clamav.inc
