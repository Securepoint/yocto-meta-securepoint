require clamav-signatures.inc 

PV = "2019-03-25"
SRC_URI[main.cvd.md5sum] = "a22e1b59c5e8b8eff166271b08b4ad72"
SRC_URI[daily.cvd.md5sum] = "e796bc368a9f5e8479082882bfa70c65"
SRC_URI[bytecode.cvd.md5sum] = "acaaee6af7482f9ab23bf6989363bbe3"
