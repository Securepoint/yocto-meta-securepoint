SRC_URI[md5sum] = "f8dcf678953f6af056ddd5917bcc50c3"
SRC_URI[sha256sum] = "9f6e3d18449f3d1a3992771d696685249dfa12736fe2b2929858f2c7d8276ae9"

require clamav.inc
