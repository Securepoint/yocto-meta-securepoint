SRC_URI[md5sum] = "61b51a04619aeafd965892a53f86d192"
SRC_URI[sha256sum] = "167bd6a13e05ece326b968fdb539b05c2ffcfef6018a274a10aeda85c2c0027a"
require clamav.inc

