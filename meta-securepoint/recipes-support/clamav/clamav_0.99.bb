require clamav.inc
SRC_URI[md5sum] = "ae79c3982761ba1815dbce17f846bab6"
SRC_URI[sha256sum] = "d2792c8cfadd685fffc40b2199679628815df031fd3149ccf961649fc8787ea9"
