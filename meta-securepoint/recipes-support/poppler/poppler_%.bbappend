PACKAGECONFIG = "jpeg png tiff"

EXTRA_OECONF += "--disable-poppler-glib"
