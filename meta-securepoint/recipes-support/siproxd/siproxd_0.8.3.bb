include siproxd.inc

SRC_URI += "file://01_no_stderr_option.patch"

SRC_URI[md5sum] = "9a9d2c89e5f0c59fdde9444a66d8372c"
SRC_URI[sha256sum] = "9a6d7a6bb6fff162775b1e1fb7018de9c69642cbf8626185dc6ffceeeba07736"

