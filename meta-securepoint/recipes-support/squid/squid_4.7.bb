require squid.inc

SRC_URI[md5sum] = "341b0dcd5e6f830e0394606083e3f2f6"
SRC_URI[sha256sum] = "4e57918abea56cb8d04f2bb4742ea6c0f113d474f75e1b86c48aa14cd0dbdc46"
