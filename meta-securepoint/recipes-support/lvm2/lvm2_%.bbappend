# udev support breaks cryptsetup open
PACKAGECONFIG = "odirect"
