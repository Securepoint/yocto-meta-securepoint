FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI += "\
    file://0049-Allow-disabling-of-SHA1-signatures.patch \
    file://0052-Allow-SHA1-in-seclevel-2-if-rh-allow-sha1-signatures.patch \
"
