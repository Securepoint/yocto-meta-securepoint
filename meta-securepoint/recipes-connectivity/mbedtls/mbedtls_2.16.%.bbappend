PV = "2.16.5"
SRC_URI[md5sum] = "339f0505323b29851ef3128a53d2de20"
SRC_URI[sha256sum] = "65b4c6cec83e048fd1c675e9a29a394ea30ad0371d37b5742453f74084e7b04d"

