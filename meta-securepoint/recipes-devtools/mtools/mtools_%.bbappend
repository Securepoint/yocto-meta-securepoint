RDEPENDS:${PN} = "kernel-module-nls-cp850"
