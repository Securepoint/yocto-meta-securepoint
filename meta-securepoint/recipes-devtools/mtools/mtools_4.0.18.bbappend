RDEPENDS_${PN} = "kernel-module-nls-cp850"
