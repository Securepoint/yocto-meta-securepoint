PV = "4.6"

SRC_URI = "git://github.com/pexpect/pexpect.git;protocol=http"
SRCREV = "ab7d99a670794fc2b0365440340b899a346422da"
S = "${WORKDIR}/git"
