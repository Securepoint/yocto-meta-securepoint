# remove systemd dep
REQUIRED_DISTRO_FEATURES = ""
